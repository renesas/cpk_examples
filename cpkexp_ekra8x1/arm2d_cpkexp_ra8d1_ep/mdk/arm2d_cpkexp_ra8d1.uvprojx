# Keil uVision project arm2d_cpkexp_ra8d1.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: R7FA8D1BH Renesas
  pack: Renesas.RA_DFP.6.0.0
  cpu: CPUTYPE("Cortex-M85") DSP TZ MVE(FP) FPU3(DFPU) PACBTI CLOCK(12000000) ELITTLE
  output: arm2d_cpkexp_ra8d1 +hex
  c flags: Optim=5 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c misc: @via/rasc_armclang.via -Wno-sign-conversion
  scatter file: .\script\fsp.scat
  link misc: --via=via/rasc_armlink.via
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c board_sdram.c board_sdram.h common_utils.h mipi_dsi_ep.c mipi_dsi_ep.h
    ./src/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
software components: Acceleration:Arm-2D Extras:Benchmark-Generic 1.5.2, Acceleration:Arm-2D Extras:Controls 2.10.3, Acceleration:Arm-2D Extras:LCD ASCII Printf 3.0.1, Acceleration:Arm-2D Helper:Display Adapter 4.0.1, Acceleration:Arm-2D Helper:PFB 3.0.0, Acceleration:Arm-2D:Alpha-Blending 1.2.4, Acceleration:Arm-2D:Core 1.2.4, Acceleration:Arm-2D:Filter 1.2.4, Acceleration:Arm-2D:Transform 1.2.4, CMSIS-Compiler:CORE 1.1.0, CMSIS:CORE 6.1.0, CMSIS:DSP 1.16.2, Utilities:perf_counter:Core 2.5.2, Flex Software:RA Configuration 1.0.0
