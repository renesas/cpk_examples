# Keil uVision project coremark_mdk.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: R7FA8D1BH Renesas
  pack: Renesas.RA_DFP.6.0.0
  cpu: CPUTYPE("Cortex-M85") DSP TZ MVE(FP) FPU3(DFPU) PACBTI CLOCK(12000000) ELITTLE
  output: coremark_mdk +hex
  c flags: Optim=4 v6Lang=4 v6LangP=6 v6Lto=1
  c misc: @via/rasc_armclang.via -Omax
  c include: src\perf_counter
  asm misc: --via=via/rasc_armasm.via
  scatter file: .\script\fsp.scat
  link misc: --via=via/rasc_armlink.via
  group :Renesas RA Smart Configurator:Common Sources
    ./src/coremark/: coremark.h core_list_join.c core_main.c core_matrix.c core_portme.c core_portme.h core_state.c core_util.c
    ./src/: hal_entry.c stdio.c
    ./src/perf_counter/: perfc_config.h perfc_port_default.c perfc_port_default.h perfc_port_pmu.c perfc_port_pmu.h perf_counter.c perf_counter.h
    ./src/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
software components: Flex Software:RA Configuration 1.0.0
