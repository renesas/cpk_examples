# Keil uVision project perf_counter_keil.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: R7KA8T2LF:CPU0 Renesas
  pack: Renesas.RA_DFP.6.5.1
  cpu: CPUTYPE("Cortex-M85") DSP TZ MVE(FP) FPU3(DFPU) PACBTI CLOCK(12000000) ELITTLE
  output: perf_counter_keil +hex
  BeforeMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out" && echo. > "$Poutput.rasc""
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: v6Lang=4 v6LangP=6
  c define: _LANGUAGE=0x0804,__PERFC_USE_PMU_PORTING__=1,__PERFC_CFG_DISABLE_DEFAULT_SYSTICK_PORTING__=1,__CODE_AREA=CODE_ITCM,__DATA_AREA=DATA_DTCM,CONSOLE_CFG_USE_UART=1
  c misc: @./via/rasc_armclang.via
  c include: .\source;.\third
  asm misc: --via=./via/rasc_armasm.via
  scatter file: .\script\fsp.scat
  link misc: --via=./via/rasc_armlink.via
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c hal_warmstart.c
  group source
    ./source/: console.c ra8p1_fault_handle.c
  group third/coremark
    ./third/coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c
  group third/perf_counter
    ./third/perf_counter/: perf_counter.c perfc_port_default.c perfc_port_pmu.c
  group third/SEGGER_RTT
    ./third/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
software components: Flex Software:RA Configuration 1.0.0
